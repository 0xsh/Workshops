<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>int(samp_rate/31.25/sps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Xmit Freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>24000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>tx_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1.0/2</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>map(ord, 'Cyberspectrum Melbourne\n')</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[math.sin(math.pi * t / 32) / 23.2 for t in xrange(32)]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>psk31_varicode_enc_bb</key>
<param><key>id</key><value>psk31_varicode_enc_bb_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>32</value></param>
<param><key>taps</key><value>[1]*32</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>psk31_varicode_enc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>psk31_varicode_enc_bb_0</source_block_id><sink_block_id>blocks_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
